Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: AndamioTalud.ifc
Time: 2026-10-12T16:23:22
Written by: IfcOpenShell 0.9.0alpha0-8c614fa
Made in: IfcOpenShell 0.9.0alpha0-8c614fa

# IfcSite, Talud
RefElevation: 0 m

# IfcBuildingStorey (4)
In: Andamio multidireccional
Name | Elevation (m)
N+0.00 Pie de talud | 0
N+2.20 Plataforma de trabajo | 2.2
N+4.20 Plataforma de torre | 4.2
N+5.20 Coronacion | 5.2

# IfcBuildingElementProxy: Escalera (2)
Description: Escalera; Material: AND_Acero galvanizado
Name | In
Escalera de acceso N+0.00 a N+2.20 | N+0.00 Pie de talud
Escalera de torre N+2.20 a N+4.20 | N+2.20 Plataforma de trabajo

# IfcBuildingElementProxy: Terreno, Talud - terreno natural
In: N+0.00 Pie de talud
Description: Terreno; Material: AND_Terreno talud

# IfcFooting: Cimentacion (16)
In: N+0.00 Pie de talud
Description: Cimentacion; PredefinedType: PAD_FOOTING
Name | Material
Dado de nivelacion E1-A | AND_Concreto
Durmiente de madera E1-A | AND_Madera durmiente
Dado de nivelacion E1-B | AND_Concreto
Durmiente de madera E1-B | AND_Madera durmiente
Dado de nivelacion E2-A | AND_Concreto
Durmiente de madera E2-A | AND_Madera durmiente
Dado de nivelacion E2-B | AND_Concreto
Durmiente de madera E2-B | AND_Madera durmiente
Dado de nivelacion E3-A | AND_Concreto
Durmiente de madera E3-A | AND_Madera durmiente
Dado de nivelacion E3-B | AND_Concreto
Durmiente de madera E3-B | AND_Madera durmiente
Dado de nivelacion E4-A | AND_Concreto
Durmiente de madera E4-A | AND_Madera durmiente
Dado de nivelacion E4-B | AND_Concreto
Durmiente de madera E4-B | AND_Madera durmiente

# IfcMember: Anclaje (2)
In: N+2.20 Plataforma de trabajo
Description: Anclaje; Material: AND_Acero galvanizado
Name
Amarre al talud A
Amarre al talud B

# IfcMember: Base regulable (8)
In: N+0.00 Pie de talud
Description: Base regulable; Material: AND_Acero galvanizado
Name
Husillo de base E1-A
Husillo de base E1-B
Husillo de base E2-A
Husillo de base E2-B
Husillo de base E3-A
Husillo de base E3-B
Husillo de base E4-A
Husillo de base E4-B

# IfcMember: Diagonal (15)
Description: Diagonal; Material: AND_Acero galvanizado
Name | In
Diagonal X E1-E2 A | N+2.20 Plataforma de trabajo
Diagonal X E1-E2 A | N+0.00 Pie de talud
Diagonal X E2-E3 A | N+0.00 Pie de talud
Diagonal X E3-E4 A | N+0.00 Pie de talud
Diagonal X E3-E4 A | N+2.20 Plataforma de trabajo
Diagonal X E1-E2 B | N+2.20 Plataforma de trabajo
Diagonal X E1-E2 B | N+0.00 Pie de talud
Diagonal X E2-E3 B | N+0.00 Pie de talud
Diagonal X E3-E4 B | N+0.00 Pie de talud
Diagonal X E3-E4 B | N+2.20 Plataforma de trabajo
Diagonal Y E1 | N+2.20 Plataforma de trabajo
Diagonal Y E2 | N+0.00 Pie de talud
Diagonal Y E3 | N+0.00 Pie de talud
Diagonal Y E4 | N+2.20 Plataforma de trabajo
Diagonal en planta E2-E3 | N+0.00 Pie de talud

# IfcMember: Larguero (12)
Description: Larguero; Material: AND_Acero galvanizado
Name | In
Larguero X E2-E3 A z=1.70 | N+0.00 Pie de talud
Larguero X E3-E4 A z=1.70 | N+0.00 Pie de talud
Larguero X E2-E3 A z=1.20 | N+0.00 Pie de talud
Larguero X E3-E4 A z=1.20 | N+0.00 Pie de talud
Larguero X E3-E4 A z=0.70 | N+0.00 Pie de talud
Larguero X E1-E2 A z=3.70 | N+2.20 Plataforma de trabajo
Larguero X E2-E3 B z=1.70 | N+0.00 Pie de talud
Larguero X E3-E4 B z=1.70 | N+0.00 Pie de talud
Larguero X E2-E3 B z=1.20 | N+0.00 Pie de talud
Larguero X E3-E4 B z=1.20 | N+0.00 Pie de talud
Larguero X E3-E4 B z=0.70 | N+0.00 Pie de talud
Larguero X E1-E2 B z=3.70 | N+2.20 Plataforma de trabajo

# IfcMember: Larguero de atado (6)
In: N+4.20 Plataforma de torre
Description: Larguero de atado; Material: AND_Acero galvanizado
Name
Larguero de atado X E2-E3 A z=4.20
Larguero de atado X E3-E4 A z=4.20
Larguero de atado X E2-E3 B z=4.20
Larguero de atado X E3-E4 B z=4.20
Larguero de atado Y E3 z=4.20
Larguero de atado Y E4 z=4.20

# IfcMember: Larguero de plataforma (8)
Description: Larguero de plataforma; Material: AND_Acero galvanizado
Name | In
Larguero de plataforma X E1-E2 A z=2.20 | N+2.20 Plataforma de trabajo
Larguero de plataforma X E2-E3 A z=2.20 | N+2.20 Plataforma de trabajo
Larguero de plataforma X E3-E4 A z=2.20 | N+2.20 Plataforma de trabajo
Larguero de plataforma X E1-E2 A z=4.20 | N+4.20 Plataforma de torre
Larguero de plataforma X E1-E2 B z=2.20 | N+2.20 Plataforma de trabajo
Larguero de plataforma X E2-E3 B z=2.20 | N+2.20 Plataforma de trabajo
Larguero de plataforma X E3-E4 B z=2.20 | N+2.20 Plataforma de trabajo
Larguero de plataforma X E1-E2 B z=4.20 | N+4.20 Plataforma de torre

# IfcMember: Montante (8)
In: N+0.00 Pie de talud
Description: Montante; Material: AND_Acero galvanizado
Name
Montante E1-A (L=3.10 m)
Montante E1-B (L=3.10 m)
Montante E2-A (L=4.10 m)
Montante E2-B (L=4.10 m)
Montante E3-A (L=3.60 m)
Montante E3-B (L=3.60 m)
Montante E4-A (L=3.60 m)
Montante E4-B (L=3.60 m)

# IfcMember: Travesano (6)
Description: Travesano; Material: AND_Acero galvanizado
Name | In
Travesano Y E2 z=1.70 | N+0.00 Pie de talud
Travesano Y E3 z=1.70 | N+0.00 Pie de talud
Travesano Y E2 z=1.20 | N+0.00 Pie de talud
Travesano Y E3 z=1.20 | N+0.00 Pie de talud
Travesano Y E3 z=0.70 | N+0.00 Pie de talud
Travesano Y E1 z=3.70 | N+2.20 Plataforma de trabajo

# IfcMember: Travesano de plataforma (6)
Description: Travesano de plataforma; Material: AND_Acero galvanizado
Name | In
Travesano de plataforma Y E1 z=2.20 | N+2.20 Plataforma de trabajo
Travesano de plataforma Y E2 z=2.20 | N+2.20 Plataforma de trabajo
Travesano de plataforma Y E3 z=2.20 | N+2.20 Plataforma de trabajo
Travesano de plataforma Y E4 z=2.20 | N+2.20 Plataforma de trabajo
Travesano de plataforma Y E1 z=4.20 | N+4.20 Plataforma de torre
Travesano de plataforma Y E2 z=4.20 | N+4.20 Plataforma de torre

# IfcPlate: Plataforma (18)
Description: Plataforma
Name | In | Material
Plataforma vano 1 z=2.20 n1 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 1 z=2.20 n2 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 1 z=2.20 n3 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 1 z=2.20 n4 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 1 z=2.20 n5 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 2 z=2.20 n1 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 2 z=2.20 n2 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 2 z=2.20 n3 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 2 z=2.20 n4 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 2 z=2.20 n5 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 3 z=2.20 n1 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 3 z=2.20 n2 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma vano 3 z=2.20 n3 | N+2.20 Plataforma de trabajo | AND_Plataforma acero
Plataforma con trampilla vano 3 z=2.20 | N+2.20 Plataforma de trabajo | AND_Trampilla amarilla
Plataforma vano 1 z=4.20 n1 | N+4.20 Plataforma de torre | AND_Plataforma acero
Plataforma vano 1 z=4.20 n2 | N+4.20 Plataforma de torre | AND_Plataforma acero
Plataforma vano 1 z=4.20 n3 | N+4.20 Plataforma de torre | AND_Plataforma acero
Plataforma con trampilla vano 1 z=4.20 | N+4.20 Plataforma de torre | AND_Trampilla amarilla

# IfcPlate: Rodapie (8)
Description: Rodapie; Material: AND_Rojo seguridad
Name | In
4 x Rodapie plataforma principal | N+2.20 Plataforma de trabajo
4 x Rodapie plataforma superior | N+4.20 Plataforma de torre

# IfcRailing: Barandilla (24)
Description: Barandilla; PredefinedType: GUARDRAIL; Material: AND_Acero galvanizado
Name | In
Barandilla X E1-E2 A z=2.70 | N+2.20 Plataforma de trabajo
Barandilla X E2-E3 A z=2.70 | N+2.20 Plataforma de trabajo
Barandilla X E3-E4 A z=2.70 | N+2.20 Plataforma de trabajo
Barandilla X E1-E2 A z=3.20 | N+2.20 Plataforma de trabajo
Barandilla X E2-E3 A z=3.20 | N+2.20 Plataforma de trabajo
Barandilla X E3-E4 A z=3.20 | N+2.20 Plataforma de trabajo
Barandilla X E1-E2 A z=4.70 | N+4.20 Plataforma de torre
Barandilla X E1-E2 A z=5.20 | N+5.20 Coronacion
Barandilla X E1-E2 B z=2.70 | N+2.20 Plataforma de trabajo
Barandilla X E2-E3 B z=2.70 | N+2.20 Plataforma de trabajo
Barandilla X E3-E4 B z=2.70 | N+2.20 Plataforma de trabajo
Barandilla X E1-E2 B z=3.20 | N+2.20 Plataforma de trabajo
Barandilla X E2-E3 B z=3.20 | N+2.20 Plataforma de trabajo
Barandilla X E3-E4 B z=3.20 | N+2.20 Plataforma de trabajo
Barandilla X E1-E2 B z=4.70 | N+4.20 Plataforma de torre
Barandilla X E1-E2 B z=5.20 | N+5.20 Coronacion
Barandilla Y E1 z=2.70 | N+2.20 Plataforma de trabajo
Barandilla Y E4 z=2.70 | N+2.20 Plataforma de trabajo
Barandilla Y E1 z=3.20 | N+2.20 Plataforma de trabajo
Barandilla Y E4 z=3.20 | N+2.20 Plataforma de trabajo
Barandilla Y E1 z=4.70 | N+4.20 Plataforma de torre
Barandilla Y E2 z=4.70 | N+4.20 Plataforma de torre
Barandilla Y E1 z=5.20 | N+5.20 Coronacion
Barandilla Y E2 z=5.20 | N+5.20 Coronacion
